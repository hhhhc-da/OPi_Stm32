# Keil uVision project stm32project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TestIO +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CORE;..\FWlib;..\System;..\Startup;..\Project;..\USER\_Main;..\USER\IIC;..\USER\Misc;..\USER\SoftTimer;..\USER\SG90;..\USER\Systick;..\USER\USART1;..\USER\USART2;..\USER\WWDG;..\USER\Event;..\Other\MQTT;..\Other\DMP;..\USER\PWM;..\USER\DAC;..\USER\myMQTT;..\USER\Esp01s;..\USER\DHT11;..\USER\MQx;..\USER\CS100A;..\USER\HX711;..\USER\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c
    ../Startup/: startup_stm32f10x_md.s
  group FWLib
    ../FWlib/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_i2c.c misc.c
  group SYSTEM
    ../System/: stm32f10x_it.c system_stm32f10x.c
  group USER
    ../USER/_Main/: main.c
    ../USER/Systick/: systick.c
    ../USER/USART1/: usart.c
    ../USER/USART2/: usart2_DMA.c
    ../USER/SoftTimer/: Timer.c
    ../USER/Event/: Event.c
    ../USER/WWDG/: wwdg.c
    ../USER/IIC/: iic.c
    ../USER/OLED/: OLED.c
    ../USER/MQx/: MQx.c
    ../USER/DHT11/: DHT11.c
    ../USER/CS100A/: CS100A.c
    ../USER/HX711/: HX711.c
software components: CMSIS:CORE 5.6.0
